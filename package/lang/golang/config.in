## package/lang/golang/config.in
```kconfig
config  PACKAGE_gin-gonic
	bool "gin (a HTTP web framework written in Golang)"
	depends on PACKAGE_golang
	default y
```
